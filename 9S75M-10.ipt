# Autodesk Inventor part: 9S75M-10
## iProperties
Created: 2007-06
Part Number: 9S75M-10
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
